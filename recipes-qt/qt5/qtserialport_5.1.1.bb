require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "83bba7e8f27d6d6d5a0d2fdcb5641d7f"
SRC_URI[sha256sum] = "aee1a277b64dc70be6d7d0504e35f2df52a83b41ab65c344119e76222ceb063b"

